Commit message: Update front_boundary_ru.urdf

File: assets/up/front_boundary_ru.urdf (robot description, URDF)
Before this commit: robot back_boundary, 1 links, 0 joints
Links:
- link back_wall: geometry collision box size=1.3 0.1 0.5; visual box size=1.3 0.1 0.5
